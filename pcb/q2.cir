* /Users/chassing/workspace/qlocktwo/pyqlocktwo/pcb/q2.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: Freitag, 27. Mai 2016 'u42' 16:42:37

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
U115  +5V WiPy
U71  +5V UDN_2981
D1  Net-_D1-Pad1_ Net-_D1-Pad2_ LED
U1  Net-_D1-Pad1_ Net-_U1-Pad2_ R
D2  Net-_D2-Pad1_ Net-_D102-Pad2_ LED
U2  Net-_D2-Pad1_ Net-_U1-Pad2_ R
D3  Net-_D3-Pad1_ Net-_D103-Pad2_ LED
U3  Net-_D3-Pad1_ Net-_U1-Pad2_ R
D4  Net-_D4-Pad1_ Net-_D104-Pad2_ LED
U4  Net-_D4-Pad1_ Net-_U1-Pad2_ R
D5  Net-_D5-Pad1_ Net-_D105-Pad2_ LED
U5  Net-_D5-Pad1_ Net-_U1-Pad2_ R
D6  Net-_D6-Pad1_ Net-_D106-Pad2_ LED
U6  Net-_D6-Pad1_ Net-_U1-Pad2_ R
D7  Net-_D7-Pad1_ Net-_D107-Pad2_ LED
U7  Net-_D7-Pad1_ Net-_U1-Pad2_ R
D8  Net-_D8-Pad1_ Net-_D108-Pad2_ LED
U8  Net-_D8-Pad1_ Net-_U1-Pad2_ R
D9  Net-_D9-Pad1_ Net-_D109-Pad2_ LED
U9  Net-_D9-Pad1_ Net-_U1-Pad2_ R
D10  Net-_D10-Pad1_ Net-_D10-Pad2_ LED
U10  Net-_D10-Pad1_ Net-_U1-Pad2_ R
D11  Net-_D11-Pad1_ Net-_D1-Pad2_ LED
U11  Net-_D11-Pad1_ Net-_U11-Pad2_ R
D12  Net-_D12-Pad1_ Net-_D102-Pad2_ LED
U12  Net-_D12-Pad1_ Net-_U11-Pad2_ R
D13  Net-_D13-Pad1_ Net-_D103-Pad2_ LED
U13  Net-_D13-Pad1_ Net-_U11-Pad2_ R
D14  Net-_D14-Pad1_ Net-_D104-Pad2_ LED
U14  Net-_D14-Pad1_ Net-_U11-Pad2_ R
D15  Net-_D15-Pad1_ Net-_D105-Pad2_ LED
U15  Net-_D15-Pad1_ Net-_U11-Pad2_ R
D16  Net-_D16-Pad1_ Net-_D106-Pad2_ LED
U16  Net-_D16-Pad1_ Net-_U11-Pad2_ R
D17  Net-_D17-Pad1_ Net-_D107-Pad2_ LED
U17  Net-_D17-Pad1_ Net-_U11-Pad2_ R
D18  Net-_D18-Pad1_ Net-_D108-Pad2_ LED
U18  Net-_D18-Pad1_ Net-_U11-Pad2_ R
D19  Net-_D19-Pad1_ Net-_D109-Pad2_ LED
U19  Net-_D19-Pad1_ Net-_U11-Pad2_ R
D20  Net-_D20-Pad1_ Net-_D10-Pad2_ LED
U20  Net-_D20-Pad1_ Net-_U11-Pad2_ R
D21  Net-_D21-Pad1_ Net-_D1-Pad2_ LED
U21  Net-_D21-Pad1_ Net-_U21-Pad2_ R
D22  Net-_D22-Pad1_ Net-_D102-Pad2_ LED
U22  Net-_D22-Pad1_ Net-_U21-Pad2_ R
D23  Net-_D23-Pad1_ Net-_D103-Pad2_ LED
U23  Net-_D23-Pad1_ Net-_U21-Pad2_ R
D24  Net-_D24-Pad1_ Net-_D104-Pad2_ LED
U24  Net-_D24-Pad1_ Net-_U21-Pad2_ R
D25  Net-_D25-Pad1_ Net-_D105-Pad2_ LED
U25  Net-_D25-Pad1_ Net-_U21-Pad2_ R
D26  Net-_D26-Pad1_ Net-_D106-Pad2_ LED
U26  Net-_D26-Pad1_ Net-_U21-Pad2_ R
D27  Net-_D27-Pad1_ Net-_D107-Pad2_ LED
U27  Net-_D27-Pad1_ Net-_U21-Pad2_ R
D28  Net-_D28-Pad1_ Net-_D108-Pad2_ LED
U28  Net-_D28-Pad1_ Net-_U21-Pad2_ R
D29  Net-_D29-Pad1_ Net-_D109-Pad2_ LED
U29  Net-_D29-Pad1_ Net-_U21-Pad2_ R
D30  Net-_D30-Pad1_ Net-_D10-Pad2_ LED
U30  Net-_D30-Pad1_ Net-_U21-Pad2_ R
D31  Net-_D31-Pad1_ Net-_D1-Pad2_ LED
U31  Net-_D31-Pad1_ Net-_U31-Pad2_ R
D32  Net-_D32-Pad1_ Net-_D102-Pad2_ LED
U32  Net-_D32-Pad1_ Net-_U31-Pad2_ R
D33  Net-_D33-Pad1_ Net-_D103-Pad2_ LED
U33  Net-_D33-Pad1_ Net-_U31-Pad2_ R
D34  Net-_D34-Pad1_ Net-_D104-Pad2_ LED
U34  Net-_D34-Pad1_ Net-_U31-Pad2_ R
D35  Net-_D35-Pad1_ Net-_D105-Pad2_ LED
U35  Net-_D35-Pad1_ Net-_U31-Pad2_ R
D36  Net-_D36-Pad1_ Net-_D106-Pad2_ LED
U36  Net-_D36-Pad1_ Net-_U31-Pad2_ R
D37  Net-_D37-Pad1_ Net-_D107-Pad2_ LED
U37  Net-_D37-Pad1_ Net-_U31-Pad2_ R
D38  Net-_D38-Pad1_ Net-_D108-Pad2_ LED
U38  Net-_D38-Pad1_ Net-_U31-Pad2_ R
D39  Net-_D39-Pad1_ Net-_D109-Pad2_ LED
U39  Net-_D39-Pad1_ Net-_U31-Pad2_ R
D40  Net-_D40-Pad1_ Net-_D10-Pad2_ LED
U40  Net-_D40-Pad1_ Net-_U31-Pad2_ R
D41  Net-_D41-Pad1_ Net-_D1-Pad2_ LED
U41  Net-_D41-Pad1_ Net-_U41-Pad2_ R
D42  Net-_D42-Pad1_ Net-_D102-Pad2_ LED
U42  Net-_D42-Pad1_ Net-_U41-Pad2_ R
D43  Net-_D43-Pad1_ Net-_D103-Pad2_ LED
U43  Net-_D43-Pad1_ Net-_U41-Pad2_ R
D44  Net-_D44-Pad1_ Net-_D104-Pad2_ LED
U44  Net-_D44-Pad1_ Net-_U41-Pad2_ R
D45  Net-_D45-Pad1_ Net-_D105-Pad2_ LED
U45  Net-_D45-Pad1_ Net-_U41-Pad2_ R
D46  Net-_D46-Pad1_ Net-_D106-Pad2_ LED
U46  Net-_D46-Pad1_ Net-_U41-Pad2_ R
D47  Net-_D47-Pad1_ Net-_D107-Pad2_ LED
U47  Net-_D47-Pad1_ Net-_U41-Pad2_ R
D48  Net-_D48-Pad1_ Net-_D108-Pad2_ LED
U48  Net-_D48-Pad1_ Net-_U41-Pad2_ R
D49  Net-_D49-Pad1_ Net-_D109-Pad2_ LED
U49  Net-_D49-Pad1_ Net-_U41-Pad2_ R
D50  Net-_D50-Pad1_ Net-_D10-Pad2_ LED
U50  Net-_D50-Pad1_ Net-_U41-Pad2_ R
D51  Net-_D51-Pad1_ Net-_D1-Pad2_ LED
U51  Net-_D51-Pad1_ Net-_U51-Pad2_ R
D52  Net-_D52-Pad1_ Net-_D102-Pad2_ LED
U52  Net-_D52-Pad1_ Net-_U51-Pad2_ R
D53  Net-_D53-Pad1_ Net-_D103-Pad2_ LED
U53  Net-_D53-Pad1_ Net-_U51-Pad2_ R
D54  Net-_D54-Pad1_ Net-_D104-Pad2_ LED
U54  Net-_D54-Pad1_ Net-_U51-Pad2_ R
D55  Net-_D55-Pad1_ Net-_D105-Pad2_ LED
U55  Net-_D55-Pad1_ Net-_U51-Pad2_ R
D56  Net-_D56-Pad1_ Net-_D106-Pad2_ LED
U56  Net-_D56-Pad1_ Net-_U51-Pad2_ R
D57  Net-_D57-Pad1_ Net-_D107-Pad2_ LED
U57  Net-_D57-Pad1_ Net-_U51-Pad2_ R
D58  Net-_D58-Pad1_ Net-_D108-Pad2_ LED
U58  Net-_D58-Pad1_ Net-_U51-Pad2_ R
D59  Net-_D59-Pad1_ Net-_D109-Pad2_ LED
U59  Net-_D59-Pad1_ Net-_U51-Pad2_ R
D60  Net-_D60-Pad1_ Net-_D10-Pad2_ LED
U60  Net-_D60-Pad1_ Net-_U51-Pad2_ R
D61  Net-_D61-Pad1_ Net-_D1-Pad2_ LED
U61  Net-_D61-Pad1_ Net-_U61-Pad2_ R
D62  Net-_D62-Pad1_ Net-_D102-Pad2_ LED
U62  Net-_D62-Pad1_ Net-_U61-Pad2_ R
D63  Net-_D63-Pad1_ Net-_D103-Pad2_ LED
U63  Net-_D63-Pad1_ Net-_U61-Pad2_ R
D64  Net-_D64-Pad1_ Net-_D104-Pad2_ LED
U64  Net-_D64-Pad1_ Net-_U61-Pad2_ R
D65  Net-_D65-Pad1_ Net-_D105-Pad2_ LED
U65  Net-_D65-Pad1_ Net-_U61-Pad2_ R
D66  Net-_D66-Pad1_ Net-_D106-Pad2_ LED
U66  Net-_D66-Pad1_ Net-_U61-Pad2_ R
D67  Net-_D67-Pad1_ Net-_D107-Pad2_ LED
U67  Net-_D67-Pad1_ Net-_U61-Pad2_ R
D68  Net-_D68-Pad1_ Net-_D108-Pad2_ LED
U68  Net-_D68-Pad1_ Net-_U61-Pad2_ R
D69  Net-_D69-Pad1_ Net-_D109-Pad2_ LED
U69  Net-_D69-Pad1_ Net-_U61-Pad2_ R
D70  Net-_D70-Pad1_ Net-_D10-Pad2_ LED
U70  Net-_D70-Pad1_ Net-_U61-Pad2_ R
D71  Net-_D71-Pad1_ Net-_D1-Pad2_ LED
U72  Net-_D71-Pad1_ Net-_U71-Pad~_ R
D72  Net-_D72-Pad1_ Net-_D102-Pad2_ LED
U73  Net-_D72-Pad1_ Net-_U71-Pad~_ R
D73  Net-_D73-Pad1_ Net-_D103-Pad2_ LED
U74  Net-_D73-Pad1_ Net-_U71-Pad~_ R
D74  Net-_D74-Pad1_ Net-_D104-Pad2_ LED
U75  Net-_D74-Pad1_ Net-_U71-Pad~_ R
D75  Net-_D75-Pad1_ Net-_D105-Pad2_ LED
U76  Net-_D75-Pad1_ Net-_U71-Pad~_ R
D76  Net-_D76-Pad1_ Net-_D106-Pad2_ LED
U77  Net-_D76-Pad1_ Net-_U71-Pad~_ R
D77  Net-_D77-Pad1_ Net-_D107-Pad2_ LED
U78  Net-_D77-Pad1_ Net-_U71-Pad~_ R
D78  Net-_D78-Pad1_ Net-_D108-Pad2_ LED
U79  Net-_D78-Pad1_ Net-_U71-Pad~_ R
D79  Net-_D79-Pad1_ Net-_D109-Pad2_ LED
U80  Net-_D79-Pad1_ Net-_U71-Pad~_ R
D80  Net-_D80-Pad1_ Net-_D10-Pad2_ LED
U81  Net-_D80-Pad1_ Net-_U71-Pad~_ R
D81  Net-_D81-Pad1_ Net-_D1-Pad2_ LED
U83  Net-_D81-Pad1_ Net-_U83-Pad2_ R
D82  Net-_D82-Pad1_ Net-_D102-Pad2_ LED
U84  Net-_D82-Pad1_ Net-_U83-Pad2_ R
D83  Net-_D83-Pad1_ Net-_D103-Pad2_ LED
U85  Net-_D83-Pad1_ Net-_U83-Pad2_ R
D84  Net-_D84-Pad1_ Net-_D104-Pad2_ LED
U86  Net-_D84-Pad1_ Net-_U83-Pad2_ R
D85  Net-_D85-Pad1_ Net-_D105-Pad2_ LED
U87  Net-_D85-Pad1_ Net-_U83-Pad2_ R
D86  Net-_D86-Pad1_ Net-_D106-Pad2_ LED
U88  Net-_D86-Pad1_ Net-_U83-Pad2_ R
D87  Net-_D87-Pad1_ Net-_D107-Pad2_ LED
U89  Net-_D87-Pad1_ Net-_U83-Pad2_ R
D88  Net-_D88-Pad1_ Net-_D108-Pad2_ LED
U90  Net-_D88-Pad1_ Net-_U83-Pad2_ R
D89  Net-_D89-Pad1_ Net-_D109-Pad2_ LED
U91  Net-_D89-Pad1_ Net-_U83-Pad2_ R
D90  Net-_D90-Pad1_ Net-_D10-Pad2_ LED
U92  Net-_D90-Pad1_ Net-_U83-Pad2_ R
D91  Net-_D91-Pad1_ Net-_D1-Pad2_ LED
U95  Net-_D91-Pad1_ Net-_U100-Pad2_ R
D92  Net-_D92-Pad1_ Net-_D102-Pad2_ LED
U96  Net-_D92-Pad1_ Net-_U100-Pad2_ R
D93  Net-_D93-Pad1_ Net-_D103-Pad2_ LED
U97  Net-_D93-Pad1_ Net-_U100-Pad2_ R
D94  Net-_D94-Pad1_ Net-_D104-Pad2_ LED
U98  Net-_D94-Pad1_ Net-_U100-Pad2_ R
D95  Net-_D95-Pad1_ Net-_D105-Pad2_ LED
U99  Net-_D95-Pad1_ Net-_U100-Pad2_ R
D96  Net-_D96-Pad1_ Net-_D106-Pad2_ LED
U100  Net-_D96-Pad1_ Net-_U100-Pad2_ R
D97  Net-_D97-Pad1_ Net-_D107-Pad2_ LED
U101  Net-_D97-Pad1_ Net-_U100-Pad2_ R
D98  Net-_D98-Pad1_ Net-_D108-Pad2_ LED
U102  Net-_D98-Pad1_ Net-_U100-Pad2_ R
D99  Net-_D99-Pad1_ Net-_D109-Pad2_ LED
U103  Net-_D99-Pad1_ Net-_U100-Pad2_ R
D100  Net-_D100-Pad1_ Net-_D10-Pad2_ LED
U104  Net-_D100-Pad1_ Net-_U100-Pad2_ R
U93  +5V UDN_2981
D101  Net-_D101-Pad1_ Net-_D1-Pad2_ LED
U105  Net-_D101-Pad1_ Net-_U105-Pad2_ R
D102  Net-_D102-Pad1_ Net-_D102-Pad2_ LED
U106  Net-_D102-Pad1_ Net-_U105-Pad2_ R
D103  Net-_D103-Pad1_ Net-_D103-Pad2_ LED
U107  Net-_D103-Pad1_ Net-_U105-Pad2_ R
D104  Net-_D104-Pad1_ Net-_D104-Pad2_ LED
U108  Net-_D104-Pad1_ Net-_U105-Pad2_ R
D105  Net-_D105-Pad1_ Net-_D105-Pad2_ LED
U109  Net-_D105-Pad1_ Net-_U105-Pad2_ R
D106  Net-_D106-Pad1_ Net-_D106-Pad2_ LED
U110  Net-_D106-Pad1_ Net-_U105-Pad2_ R
D107  Net-_D107-Pad1_ Net-_D107-Pad2_ LED
U111  Net-_D107-Pad1_ Net-_U105-Pad2_ R
D108  Net-_D108-Pad1_ Net-_D108-Pad2_ LED
U112  Net-_D108-Pad1_ Net-_U105-Pad2_ R
D109  Net-_D109-Pad1_ Net-_D109-Pad2_ LED
U113  Net-_D109-Pad1_ Net-_U105-Pad2_ 16
D110  Net-_D110-Pad1_ Net-_D10-Pad2_ LED
U114  Net-_D110-Pad1_ Net-_U105-Pad2_ R
U117  Net-_D10-Pad2_ UDN_2981
U116  Net-_D103-Pad2_ UDN_2981
C5  +5V GND 100nF
C6  +5V GND 100nF
C3  +5V GND 100nF
C1  +5V GND 100nF
C2  +5V GND 100nF
C4  +5V GND 100nF
C7  +5V GND 100nF
C8  +5V GND 100nF
U119  Net-_U117-Pad~_ ? ? ? ? ? ? GND ? +5V /latch /latch GND Net-_U118-Pad9_ Net-_U117-Pad~_ +5V 74HC595
U118  Net-_U116-Pad~_ Net-_U116-Pad~_ Net-_U116-Pad~_ Net-_U116-Pad~_ Net-_U116-Pad~_ Net-_U116-Pad~_ Net-_U116-Pad~_ GND Net-_U118-Pad9_ +5V /latch /latch GND Net-_U118-Pad14_ Net-_U116-Pad~_ +5V 74HC595
U94  Net-_U93-Pad~_ Net-_U93-Pad~_ Net-_U93-Pad~_ Net-_U93-Pad~_ Net-_U93-Pad~_ Net-_U93-Pad~_ Net-_U93-Pad~_ GND Net-_U118-Pad14_ +5V /latch /latch GND /data Net-_U93-Pad~_ +5V 74HC595
U82  Net-_U71-Pad~_ Net-_U71-Pad~_ Net-_U71-Pad~_ Net-_U71-Pad~_ Net-_U71-Pad~_ Net-_U71-Pad~_ Net-_U71-Pad~_ GND /data +5V /latch /latch GND Net-_U115-Pad~_ Net-_U71-Pad~_ +5V 74HC595

.end
